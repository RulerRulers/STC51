# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: main.c time.c STARTUP.A51 console.c util.c xmodem.c tft-lcd.c
  group res
    ./src/res/: font.c
  group driver
    ./src/: m25p80.c eeprom.c rtc.c uart1.c led.c key.c ir.c
  group pff
    ./src/pff/: diskio.c pff-test.c pff.c
  group head
    ./src/: global.h
