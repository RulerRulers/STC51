# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: ir.c key.c led.c main.c time.c uart1.c STARTUP.A51 global.h console.c util.c rtc.c eeprom.c m25p80.c xmodem.c
    ./src/pff/: diskio.c pff.c pff-test.c
