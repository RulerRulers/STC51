# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: main.c time.c STARTUP.A51 console.c util.c xmodem.c tft-lcd.c
  group res
    ./src/res/: font.c
  group driver
    ./src/: m25p80.c eeprom.c rtc.c uart1.c led.c key.c ir.c adc.c buzzer.c
  group pff
    ./src/pff/: diskio.c pff-test.c pff.c
  group head
    ./src/: global.h
  group gui
    ./src/gui/: dlg_adcDemo.c dlg_desktop.c dlg_eepromDemo.c dlg_FlashDemo.c dlg_IrDemo.c dlg_KeyDemo.c dlg_LedDemo.c dlg_mainmenu.c dlg_mainmenu_2.c dlg_RtcDemo.c dlg_SDCardDemo.c dlg_TFTDemo.c gui.c
